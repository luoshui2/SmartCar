# Keil uVision project Smartcar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Smartcar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c move.c Delay.c avoid.c LED.c Linepatorl.c control.c follow.c Int1.c Int1.h IR.c IR.h Timer1.c Timer1.h Int0.c Buzzer.c control.h avoid.h Linepatorl.h follow.h Delay10us.c move.h Timer2.c oled.c oled.h oledfont.h Screen.c measure.c
